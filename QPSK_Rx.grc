options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: QPSK_Rx
    output_language: python
  states: {}

blocks:
- name: arity
  id: variable
  parameters:
    value: '4'
  states: {}
- name: eq_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: 'Equalizer: rate'
    orient: Qt.Horizontal
    start: '0.0'
    step: '0.001'
    stop: '0.1'
    value: '0.01'
    widget: slider
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: phase_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: 'Phase: Bandwidth'
    orient: Qt.Horizontal
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: 6.28/100.0
    widget: slider
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: symbol_map
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '16'
  states: {}
- name: symbol_map
  id: variable
  parameters:
    value: '[0,1,2,3]'
  states: {}
- name: timing_loop_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: 'Time: BW'
    orient: Qt.Horizontal
    start: '0.0'
    step: '0.01'
    stop: '0.2'
    value: 6.28/100.0
    widget: slider
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/bd4sur/out.txt
    type: byte
  states: {}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: digital_cma_equalizer_cc_0
  id: digital_cma_equalizer_cc
  parameters:
    modulus: '1'
    mu: eq_gain
    num_taps: '15'
    sps: 2 * sps
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"11100001010110101110100010010011"'
    tagname: packet_len
    threshold: '2'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: arity
    w: phase_bw
  states: {}
- name: digital_crc32_async_bb_0
  id: digital_crc32_async_bb
  parameters:
    check: 'True'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '4'
  states: {}
- name: digital_lms_dd_equalizer_cc_0
  id: digital_lms_dd_equalizer_cc
  parameters:
    cnst: qpsk
    mu: '0.01'
    num_taps: '15'
    sps: 2 * sps
  states: {state: disabled}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: symbol_map
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: timing_loop_bw
    max_dev: '1.5'
    osps: 2 * sps
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport pmt\nimport queue\n\nclass blk(gr.sync_block):\n\n    def __init__(self):\n        gr.sync_block.__init__(\n            self,\n            name = 'PDU to File',\n            in_sig = None,\n            out_sig = [np.uint8]\n        )\n        self.message_port_register_in(pmt.intern(\"message_in\"))\n        self.set_msg_handler(pmt.intern(\"message_in\"), self.handle_msg)\n        \n        self.msg_queue = queue.Queue()\n        self.msg_counter = 0\n\n\n    def work(self, input_items, output_items):\n        out = output_items[0]\n        if not self.msg_queue.empty():\n            self.msg_counter += 1\n            payload = self.msg_queue.get()\n            payload_length = len(payload)\n            out[:payload_length] = payload\n            return payload_length\n        else:\n            return 0\n\n    def handle_msg(self, msg):\n        payload = pmt.to_python(pmt.cdr(msg))\n        self.msg_queue.put(payload)\n\n"
  states: {}
- name: kc_sdr_source_0
  id: kc_sdr_source
  parameters:
    amp: '20'
    att: '0'
    bandwidth: int(2e6)
    cent_freq: int(439e6)
    ifgain: '20'
    port: '2'
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 1,0,1,1
    size: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 2e6
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,1,1,2
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: 439e6
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: 2e6
    sync: sync
    type: fc32
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:49203
    comment: USRP sample rate = 768kHz
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [blocks_repack_bits_bb_1_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, digital_crc32_async_bb_0, in]
- [blocks_unpack_k_bits_bb_0, '0', digital_correlate_access_code_xx_ts_0_0_0_0, '0']
- [digital_cma_equalizer_cc_0, '0', digital_costas_loop_cc_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_correlate_access_code_xx_ts_0_0_0_0, '0', blocks_repack_bits_bb_1_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_crc32_async_bb_0, out, epy_block_1, message_in]
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_lms_dd_equalizer_cc_0, '0', digital_costas_loop_cc_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_cma_equalizer_cc_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_lms_dd_equalizer_cc_0, '0']
- [epy_block_1, '0', blocks_file_sink_0, '0']
- [kc_sdr_source_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [rtlsdr_source_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [zeromq_sub_source_0, '0', digital_pfb_clock_sync_xxx_0, '0']

metadata:
  file_format: 1
