options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: QPSK_Tx
    output_language: python
  states: {}

blocks:
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: symbol_map
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: symbol_map
  id: variable
  parameters:
    value: '[0,1,2,3]'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '50'
    value: '50'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    begin_tag: pmt.intern("file_begin")
    file: /home/bd4sur/_Audio/01 - 絶対カラフル宣言.wav
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '48000'
    type: byte
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: '16'
  states: {}
- name: digital_crc32_async_bb_1
  id: digital_crc32_async_bb
  parameters:
    check: 'False'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport pmt\nimport math\n\nclass blk(gr.sync_block):\n\n    def __init__(self, frame_length=1024):\n        gr.sync_block.__init__(\n            self,\n            name = 'File to PDU',\n            in_sig = [np.uint8],\n            out_sig = None\n        )\n        self.frame_length = frame_length\n        self.message_port_register_out(pmt.intern(\"message_out\"))\n\n    def work(self, input_items, output_items):\n        input_buf = np.copy(input_items[0])\n        frame_count = math.ceil(len(input_buf) / self.frame_length)\n\n        for i in range(frame_count):\n            frame = input_buf[i * self.frame_length : (i+1) * self.frame_length]\n            output_list = frame.tolist()\n            output_message = pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(output_list), (output_list)))\n            self.message_port_pub(pmt.intern(\"message_out\"), output_message)\n\n        return len(input_items[0])\n\n\n\n\n"
    frame_length: '1024'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: kc_sdr_transmitter_0
  id: kc_sdr_transmitter
  parameters:
    att: '0'
    bandwidth: int(2e6)
    cent_freq: int(439e6)
    ifgain: tx_gain
    port: '1'
  states: {}
- name: packet_format_gr38
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import array
      class blk(gr.sync_block):
          """Packet Format"""

          def __init__(self):
              gr.sync_block.__init__(self,
                  name = "Packet Format GR38",
                  in_sig = None,
                  out_sig = None)
              self.message_port_register_in(pmt.intern('PDU_in'))
              self.message_port_register_out(pmt.intern('PDU_out0'))
              self.set_msg_handler(pmt.intern('PDU_in'), self.handle_msg)

          def handle_msg(self, msg):
              inMsg = pmt.to_python (msg)
              pld = inMsg[1] ## type-> numpy.ndarray
              mLen = len(pld)
              if (mLen > 0):
                  ## create a numpy array of type 'int' with preamble and sync word
                  tmp_char_list = np.array([85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,225,90,232,147],dtype=int)
                  ## append length 2x
                  tmp_char_list=np.append(tmp_char_list,(mLen >> 8))
                  tmp_char_list=np.append(tmp_char_list,(mLen & 255))
                  tmp_char_list=np.append(tmp_char_list,(mLen >> 8))
                  tmp_char_list=np.append(tmp_char_list,(mLen & 255))
                  tmp_char_list_len=len(tmp_char_list)
                  ## append original payload
                  new_char_list=np.insert(tmp_char_list,tmp_char_list_len,pld)
                  new_char_list_len=len(new_char_list)
                  ## save final numpy array as byte array (requires 'import array')
                  byte_array_new_char_list=array.array('B',new_char_list)
                  new_bytes_out_len = len(byte_array_new_char_list)
                  ## create PMT u8vector using byte array
                  new_out_bytes_pmt=pmt.cons(pmt.PMT_NIL,pmt.init_u8vector(new_bytes_out_len,(byte_array_new_char_list)))
                  self.message_port_pub(pmt.intern('PDU_out0'), new_out_bytes_pmt)
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:49203
    comment: USRP sample rate = 768kHz
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [blocks_complex_to_float_0, '0', blocks_float_to_complex_0, '1']
- [blocks_complex_to_float_0, '1', blocks_float_to_complex_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_float_to_complex_0, '0', kc_sdr_transmitter_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', digital_constellation_modulator_0, '0']
- [blocks_throttle_0, '0', epy_block_0, '0']
- [digital_constellation_modulator_0, '0', blocks_complex_to_float_0, '0']
- [digital_crc32_async_bb_1, out, packet_format_gr38, PDU_in]
- [epy_block_0, message_out, digital_crc32_async_bb_1, in]
- [packet_format_gr38, PDU_out0, blocks_pdu_to_tagged_stream_0, pdus]

metadata:
  file_format: 1
